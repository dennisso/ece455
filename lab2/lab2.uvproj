# Keil uVision project lab2.uvproj, settings and files
target lpc1768 flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lab2
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group lib
    ./src/: GLCD_SPI_LPC1700.c system_LPC17xx.c startup_LPC17xx.s
  group header
    ./src/: Font_6x8_h.h Font_16x24_h.h GLCD.h
  group src
    ./src/: main.c
